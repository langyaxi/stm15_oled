# Keil uVision project WQX.uvproj, settings and files
target stc15 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: WQX +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\c_and h_
  group Source
    ./c_and h_/: IIC_Drive.c main.c ASCII.C OLED12864pic.c
  group include
    ./c_and h_/: all.h IIC_Drive.h ASCII.h OLED12864pic.h
